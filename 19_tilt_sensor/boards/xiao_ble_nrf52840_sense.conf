## 19_tilt_sensor/boards/xiao_ble_nrf52840_sense.conf
```kconfig
CONFIG_LSM6DSL=y
CONFIG_LSM6DSL_TRIGGER_GLOBAL_THREAD=y
CONFIG_I2C=y
CONFIG_LOG_DEFAULT_LEVEL=4
```
